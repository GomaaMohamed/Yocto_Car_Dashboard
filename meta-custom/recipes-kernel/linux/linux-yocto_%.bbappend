FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-calibrate.c-Added-some-printk-statements.patch"
SRC_URI += "file://defconfig"
SRC_URI += "file://fragment.cfg"
